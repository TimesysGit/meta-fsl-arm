# Copyright (C) 2013-2015 Freescale Semiconductor

require imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=3880bb9c943b135a30fad5e8aabd3ee9"

PE = "1"

SRC_URI[md5sum] = "2587d0d011b65021aef469d17ca5c658"
SRC_URI[sha256sum] = "a266ab317fbd866541eae506d68983bcd361f49d1162a66bb34cb8088ceec88c"

COMPATIBLE_MACHINE = "(mx6)"
